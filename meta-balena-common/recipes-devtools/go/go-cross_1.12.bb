require go-${PV}.inc
require go-cross-${GO_BASEVERSION}.inc
