require go-${PV}.inc
require ${PN}-${GO_BASEVERSION}.inc
