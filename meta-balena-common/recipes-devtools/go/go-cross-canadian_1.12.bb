require go-${PV}.inc
require go-cross-canadian-${GO_BASEVERSION}.inc
