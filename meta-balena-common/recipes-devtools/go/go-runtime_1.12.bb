require go-${PV}.inc
require go-runtime-${GO_BASEVERSION}.inc
