require go-${PV}.inc
require go-crosssdk-${GO_BASEVERSION}.inc
